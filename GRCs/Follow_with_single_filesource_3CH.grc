<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Sequence_Follower</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/hocheol/GRC/Sample/FHSS_Sig</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>64</value></param>
<param><key>taps</key><value> [0.00025175302289426327, 0.0002478941751178354, 0.00024384097196161747, 0.00023943278938531876, 0.00023445764963980764, 0.00022865414211992174, 0.00022171477030497044, 0.00021328983712010086, 0.00020299253810662776, 0.0001904050150187686, 0.00017508499149698764, 0.00015657344192732126, 0.00013440292968880385, 0.00010810644744196907, 7.722696318523958e-05, 4.1327231883769855e-05, -1.3773695864819878e-19, -4.712164445663802e-05, -0.00010035386367235333, -0.00015995172725524753, -0.00022609918960370123, -0.000298899132758379, -0.00037836440606042743, -0.0004644088912755251, -0.0005568398046307266, -0.0006553506827913225, -0.0007595152128487825, -0.0008687828085385263, -0.0009824740700423717, -0.0010997796198353171, -0.001219758065417409, -0.0013413368724286556, -0.0014633144019171596, -0.0015843634027987719, -0.001703036017715931, -0.0018177700694650412, -0.0019268979085609317, -0.0020286552608013153, -0.002121193567290902, -0.002202590461820364, -0.002270865486934781, -0.002323994878679514, -0.0023599271662533283, -0.0023765997029840946, -0.0023719584569334984, -0.0023439752403646708, -0.002290667500346899, -0.0022101167123764753, -0.002100490964949131, -0.0019600610248744488, -0.0017872219905257225, -0.0015805121511220932, -0.0013386312639340758, -0.0010604579001665115, -0.0007450666162185371, -0.00039174340781755745, 6.409487041537445e-19, 0.00043041346361860633, 0.0008994973031803966, 0.0014069929020479321, 0.0019523754017427564, 0.002534848405048251, 0.0031533404253423214, 0.0038065039552748203, 0.0044927168637514114, 0.005210085306316614, 0.005956450942903757, 0.0067293960601091385, 0.007526257541030645, 0.008344138041138649, 0.0091799171641469, 0.010030274279415607, 0.010891705751419067, 0.011760538443922997, 0.012632963247597218, 0.013505049049854279, 0.014372773468494415, 0.01523204892873764, 0.01607874222099781, 0.016908716410398483, 0.017717842012643814, 0.018502041697502136, 0.019257301464676857, 0.019979722797870636, 0.020665522664785385, 0.021311080083251, 0.021912956610322, 0.022467920556664467, 0.022972973063588142, 0.023425361141562462, 0.023822613060474396, 0.024162547662854195, 0.024443281814455986, 0.02466326393187046, 0.02482127584517002, 0.024916434660553932, 0.02494821511209011, 0.024916434660553932, 0.02482127584517002, 0.02466326393187046, 0.024443281814455986, 0.024162547662854195, 0.023822613060474396, 0.023425361141562462, 0.022972973063588142, 0.022467920556664467, 0.021912956610322, 0.021311080083251, 0.020665522664785385, 0.019979722797870636, 0.019257301464676857, 0.018502041697502136, 0.017717842012643814, 0.016908716410398483, 0.01607874222099781, 0.01523204892873764, 0.014372773468494415, 0.013505049049854279, 0.012632963247597218, 0.011760538443922997, 0.010891705751419067, 0.010030274279415607, 0.0091799171641469, 0.008344138041138649, 0.007526257541030645, 0.0067293960601091385, 0.005956450942903757, 0.005210085306316614, 0.0044927168637514114, 0.0038065039552748203, 0.0031533404253423214, 0.002534848405048251, 0.0019523754017427564, 0.0014069929020479321, 0.0008994973031803966, 0.00043041346361860633, 6.409487041537445e-19, -0.00039174340781755745, -0.0007450666162185371, -0.0010604579001665115, -0.0013386312639340758, -0.0015805121511220932, -0.0017872219905257225, -0.0019600610248744488, -0.002100490964949131, -0.0022101167123764753, -0.002290667500346899, -0.0023439752403646708, -0.0023719584569334984, -0.0023765997029840946, -0.0023599271662533283, -0.002323994878679514, -0.002270865486934781, -0.002202590461820364, -0.002121193567290902, -0.0020286552608013153, -0.0019268979085609317, -0.0018177700694650412, -0.001703036017715931, -0.0015843634027987719, -0.0014633144019171596, -0.0013413368724286556, -0.001219758065417409, -0.0010997796198353171, -0.0009824740700423717, -0.0008687828085385263, -0.0007595152128487825, -0.0006553506827913225, -0.0005568398046307266, -0.0004644088912755251, -0.00037836440606042743, -0.000298899132758379, -0.00022609918960370123, -0.00015995172725524753, -0.00010035386367235333, -4.712164445663802e-05, -1.3773695864819878e-19, 4.1327231883769855e-05, 7.722696318523958e-05, 0.00010810644744196907, 0.00013440292968880385, 0.00015657344192732126, 0.00017508499149698764, 0.0001904050150187686, 0.00020299253810662776, 0.00021328983712010086, 0.00022171477030497044, 0.00022865414211992174, 0.00023445764963980764, 0.00023943278938531876, 0.00024384097196161747, 0.0002478941751178354, 0.00025175302289426327]</value></param>
<param><key>center_freq</key><value>1000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/hocheol/GRC/Sample/Sequence_Demodulated0.cfloat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>64</value></param>
<param><key>taps</key><value> [0.00025175302289426327, 0.0002478941751178354, 0.00024384097196161747, 0.00023943278938531876, 0.00023445764963980764, 0.00022865414211992174, 0.00022171477030497044, 0.00021328983712010086, 0.00020299253810662776, 0.0001904050150187686, 0.00017508499149698764, 0.00015657344192732126, 0.00013440292968880385, 0.00010810644744196907, 7.722696318523958e-05, 4.1327231883769855e-05, -1.3773695864819878e-19, -4.712164445663802e-05, -0.00010035386367235333, -0.00015995172725524753, -0.00022609918960370123, -0.000298899132758379, -0.00037836440606042743, -0.0004644088912755251, -0.0005568398046307266, -0.0006553506827913225, -0.0007595152128487825, -0.0008687828085385263, -0.0009824740700423717, -0.0010997796198353171, -0.001219758065417409, -0.0013413368724286556, -0.0014633144019171596, -0.0015843634027987719, -0.001703036017715931, -0.0018177700694650412, -0.0019268979085609317, -0.0020286552608013153, -0.002121193567290902, -0.002202590461820364, -0.002270865486934781, -0.002323994878679514, -0.0023599271662533283, -0.0023765997029840946, -0.0023719584569334984, -0.0023439752403646708, -0.002290667500346899, -0.0022101167123764753, -0.002100490964949131, -0.0019600610248744488, -0.0017872219905257225, -0.0015805121511220932, -0.0013386312639340758, -0.0010604579001665115, -0.0007450666162185371, -0.00039174340781755745, 6.409487041537445e-19, 0.00043041346361860633, 0.0008994973031803966, 0.0014069929020479321, 0.0019523754017427564, 0.002534848405048251, 0.0031533404253423214, 0.0038065039552748203, 0.0044927168637514114, 0.005210085306316614, 0.005956450942903757, 0.0067293960601091385, 0.007526257541030645, 0.008344138041138649, 0.0091799171641469, 0.010030274279415607, 0.010891705751419067, 0.011760538443922997, 0.012632963247597218, 0.013505049049854279, 0.014372773468494415, 0.01523204892873764, 0.01607874222099781, 0.016908716410398483, 0.017717842012643814, 0.018502041697502136, 0.019257301464676857, 0.019979722797870636, 0.020665522664785385, 0.021311080083251, 0.021912956610322, 0.022467920556664467, 0.022972973063588142, 0.023425361141562462, 0.023822613060474396, 0.024162547662854195, 0.024443281814455986, 0.02466326393187046, 0.02482127584517002, 0.024916434660553932, 0.02494821511209011, 0.024916434660553932, 0.02482127584517002, 0.02466326393187046, 0.024443281814455986, 0.024162547662854195, 0.023822613060474396, 0.023425361141562462, 0.022972973063588142, 0.022467920556664467, 0.021912956610322, 0.021311080083251, 0.020665522664785385, 0.019979722797870636, 0.019257301464676857, 0.018502041697502136, 0.017717842012643814, 0.016908716410398483, 0.01607874222099781, 0.01523204892873764, 0.014372773468494415, 0.013505049049854279, 0.012632963247597218, 0.011760538443922997, 0.010891705751419067, 0.010030274279415607, 0.0091799171641469, 0.008344138041138649, 0.007526257541030645, 0.0067293960601091385, 0.005956450942903757, 0.005210085306316614, 0.0044927168637514114, 0.0038065039552748203, 0.0031533404253423214, 0.002534848405048251, 0.0019523754017427564, 0.0014069929020479321, 0.0008994973031803966, 0.00043041346361860633, 6.409487041537445e-19, -0.00039174340781755745, -0.0007450666162185371, -0.0010604579001665115, -0.0013386312639340758, -0.0015805121511220932, -0.0017872219905257225, -0.0019600610248744488, -0.002100490964949131, -0.0022101167123764753, -0.002290667500346899, -0.0023439752403646708, -0.0023719584569334984, -0.0023765997029840946, -0.0023599271662533283, -0.002323994878679514, -0.002270865486934781, -0.002202590461820364, -0.002121193567290902, -0.0020286552608013153, -0.0019268979085609317, -0.0018177700694650412, -0.001703036017715931, -0.0015843634027987719, -0.0014633144019171596, -0.0013413368724286556, -0.001219758065417409, -0.0010997796198353171, -0.0009824740700423717, -0.0008687828085385263, -0.0007595152128487825, -0.0006553506827913225, -0.0005568398046307266, -0.0004644088912755251, -0.00037836440606042743, -0.000298899132758379, -0.00022609918960370123, -0.00015995172725524753, -0.00010035386367235333, -4.712164445663802e-05, -1.3773695864819878e-19, 4.1327231883769855e-05, 7.722696318523958e-05, 0.00010810644744196907, 0.00013440292968880385, 0.00015657344192732126, 0.00017508499149698764, 0.0001904050150187686, 0.00020299253810662776, 0.00021328983712010086, 0.00022171477030497044, 0.00022865414211992174, 0.00023445764963980764, 0.00023943278938531876, 0.00024384097196161747, 0.0002478941751178354, 0.00025175302289426327]</value></param>
<param><key>center_freq</key><value>2000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>64</value></param>
<param><key>taps</key><value> [0.00025175302289426327, 0.0002478941751178354, 0.00024384097196161747, 0.00023943278938531876, 0.00023445764963980764, 0.00022865414211992174, 0.00022171477030497044, 0.00021328983712010086, 0.00020299253810662776, 0.0001904050150187686, 0.00017508499149698764, 0.00015657344192732126, 0.00013440292968880385, 0.00010810644744196907, 7.722696318523958e-05, 4.1327231883769855e-05, -1.3773695864819878e-19, -4.712164445663802e-05, -0.00010035386367235333, -0.00015995172725524753, -0.00022609918960370123, -0.000298899132758379, -0.00037836440606042743, -0.0004644088912755251, -0.0005568398046307266, -0.0006553506827913225, -0.0007595152128487825, -0.0008687828085385263, -0.0009824740700423717, -0.0010997796198353171, -0.001219758065417409, -0.0013413368724286556, -0.0014633144019171596, -0.0015843634027987719, -0.001703036017715931, -0.0018177700694650412, -0.0019268979085609317, -0.0020286552608013153, -0.002121193567290902, -0.002202590461820364, -0.002270865486934781, -0.002323994878679514, -0.0023599271662533283, -0.0023765997029840946, -0.0023719584569334984, -0.0023439752403646708, -0.002290667500346899, -0.0022101167123764753, -0.002100490964949131, -0.0019600610248744488, -0.0017872219905257225, -0.0015805121511220932, -0.0013386312639340758, -0.0010604579001665115, -0.0007450666162185371, -0.00039174340781755745, 6.409487041537445e-19, 0.00043041346361860633, 0.0008994973031803966, 0.0014069929020479321, 0.0019523754017427564, 0.002534848405048251, 0.0031533404253423214, 0.0038065039552748203, 0.0044927168637514114, 0.005210085306316614, 0.005956450942903757, 0.0067293960601091385, 0.007526257541030645, 0.008344138041138649, 0.0091799171641469, 0.010030274279415607, 0.010891705751419067, 0.011760538443922997, 0.012632963247597218, 0.013505049049854279, 0.014372773468494415, 0.01523204892873764, 0.01607874222099781, 0.016908716410398483, 0.017717842012643814, 0.018502041697502136, 0.019257301464676857, 0.019979722797870636, 0.020665522664785385, 0.021311080083251, 0.021912956610322, 0.022467920556664467, 0.022972973063588142, 0.023425361141562462, 0.023822613060474396, 0.024162547662854195, 0.024443281814455986, 0.02466326393187046, 0.02482127584517002, 0.024916434660553932, 0.02494821511209011, 0.024916434660553932, 0.02482127584517002, 0.02466326393187046, 0.024443281814455986, 0.024162547662854195, 0.023822613060474396, 0.023425361141562462, 0.022972973063588142, 0.022467920556664467, 0.021912956610322, 0.021311080083251, 0.020665522664785385, 0.019979722797870636, 0.019257301464676857, 0.018502041697502136, 0.017717842012643814, 0.016908716410398483, 0.01607874222099781, 0.01523204892873764, 0.014372773468494415, 0.013505049049854279, 0.012632963247597218, 0.011760538443922997, 0.010891705751419067, 0.010030274279415607, 0.0091799171641469, 0.008344138041138649, 0.007526257541030645, 0.0067293960601091385, 0.005956450942903757, 0.005210085306316614, 0.0044927168637514114, 0.0038065039552748203, 0.0031533404253423214, 0.002534848405048251, 0.0019523754017427564, 0.0014069929020479321, 0.0008994973031803966, 0.00043041346361860633, 6.409487041537445e-19, -0.00039174340781755745, -0.0007450666162185371, -0.0010604579001665115, -0.0013386312639340758, -0.0015805121511220932, -0.0017872219905257225, -0.0019600610248744488, -0.002100490964949131, -0.0022101167123764753, -0.002290667500346899, -0.0023439752403646708, -0.0023719584569334984, -0.0023765997029840946, -0.0023599271662533283, -0.002323994878679514, -0.002270865486934781, -0.002202590461820364, -0.002121193567290902, -0.0020286552608013153, -0.0019268979085609317, -0.0018177700694650412, -0.001703036017715931, -0.0015843634027987719, -0.0014633144019171596, -0.0013413368724286556, -0.001219758065417409, -0.0010997796198353171, -0.0009824740700423717, -0.0008687828085385263, -0.0007595152128487825, -0.0006553506827913225, -0.0005568398046307266, -0.0004644088912755251, -0.00037836440606042743, -0.000298899132758379, -0.00022609918960370123, -0.00015995172725524753, -0.00010035386367235333, -4.712164445663802e-05, -1.3773695864819878e-19, 4.1327231883769855e-05, 7.722696318523958e-05, 0.00010810644744196907, 0.00013440292968880385, 0.00015657344192732126, 0.00017508499149698764, 0.0001904050150187686, 0.00020299253810662776, 0.00021328983712010086, 0.00022171477030497044, 0.00022865414211992174, 0.00023445764963980764, 0.00023943278938531876, 0.00024384097196161747, 0.0002478941751178354, 0.00025175302289426327]</value></param>
<param><key>center_freq</key><value>3000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-25</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>50</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sql_on</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sql_on_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>analog_pwr_squelch_xx_0_1</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sql_on_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-25</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>50</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-25</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>50</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
