<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Sequence_extractor</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25000000</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(-0.0010285986354574561, -0.0009848017944023013, -0.0009711346356198192, -0.0009126878576353192, -0.0007082896772772074, -0.00023802171926945448, 0.0006265888805501163, 0.002010512864217162, 0.004022321198135614, 0.006741601508110762, 0.01020786166191101, 0.014412014745175838, 0.019291354343295097, 0.024728646501898766, 0.030555615201592445, 0.036560770124197006, 0.042501047253608704, 0.048116534948349, 0.05314710736274719, 0.05734973028302193, 0.060515083372592926, 0.062482092529535294, 0.06314931064844131, 0.062482092529535294, 0.060515083372592926, 0.05734973028302193, 0.05314710736274719, 0.048116534948349, 0.042501047253608704, 0.036560770124197006, 0.030555615201592445, 0.024728646501898766, 0.019291354343295097, 0.014412014745175838, 0.01020786166191101, 0.006741601508110762, 0.004022321198135614, 0.002010512864217162, 0.0006265888805501163, -0.00023802171926945448, -0.0007082896772772074, -0.0009126878576353192, -0.0009711346356198192, -0.0009848017944023013, -0.0010285986354574561)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_2</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(-0.0010285986354574561, -0.0009848017944023013, -0.0009711346356198192, -0.0009126878576353192, -0.0007082896772772074, -0.00023802171926945448, 0.0006265888805501163, 0.002010512864217162, 0.004022321198135614, 0.006741601508110762, 0.01020786166191101, 0.014412014745175838, 0.019291354343295097, 0.024728646501898766, 0.030555615201592445, 0.036560770124197006, 0.042501047253608704, 0.048116534948349, 0.05314710736274719, 0.05734973028302193, 0.060515083372592926, 0.062482092529535294, 0.06314931064844131, 0.062482092529535294, 0.060515083372592926, 0.05734973028302193, 0.05314710736274719, 0.048116534948349, 0.042501047253608704, 0.036560770124197006, 0.030555615201592445, 0.024728646501898766, 0.019291354343295097, 0.014412014745175838, 0.01020786166191101, 0.006741601508110762, 0.004022321198135614, 0.002010512864217162, 0.0006265888805501163, -0.00023802171926945448, -0.0007082896772772074, -0.0009126878576353192, -0.0009711346356198192, -0.0009848017944023013, -0.0010285986354574561)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(-0.0010285986354574561, -0.0009848017944023013, -0.0009711346356198192, -0.0009126878576353192, -0.0007082896772772074, -0.00023802171926945448, 0.0006265888805501163, 0.002010512864217162, 0.004022321198135614, 0.006741601508110762, 0.01020786166191101, 0.014412014745175838, 0.019291354343295097, 0.024728646501898766, 0.030555615201592445, 0.036560770124197006, 0.042501047253608704, 0.048116534948349, 0.05314710736274719, 0.05734973028302193, 0.060515083372592926, 0.062482092529535294, 0.06314931064844131, 0.062482092529535294, 0.060515083372592926, 0.05734973028302193, 0.05314710736274719, 0.048116534948349, 0.042501047253608704, 0.036560770124197006, 0.030555615201592445, 0.024728646501898766, 0.019291354343295097, 0.014412014745175838, 0.01020786166191101, 0.006741601508110762, 0.004022321198135614, 0.002010512864217162, 0.0006265888805501163, -0.00023802171926945448, -0.0007082896772772074, -0.0009126878576353192, -0.0009711346356198192, -0.0009848017944023013, -0.0010285986354574561)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_1</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_xlating_fir_filter_xxx_0_2</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0_3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_xlating_fir_filter_xxx_0_3</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>25</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(-0.0010285986354574561, -0.0009848017944023013, -0.0009711346356198192, -0.0009126878576353192, -0.0007082896772772074, -0.00023802171926945448, 0.0006265888805501163, 0.002010512864217162, 0.004022321198135614, 0.006741601508110762, 0.01020786166191101, 0.014412014745175838, 0.019291354343295097, 0.024728646501898766, 0.030555615201592445, 0.036560770124197006, 0.042501047253608704, 0.048116534948349, 0.05314710736274719, 0.05734973028302193, 0.060515083372592926, 0.062482092529535294, 0.06314931064844131, 0.062482092529535294, 0.060515083372592926, 0.05734973028302193, 0.05314710736274719, 0.048116534948349, 0.042501047253608704, 0.036560770124197006, 0.030555615201592445, 0.024728646501898766, 0.019291354343295097, 0.014412014745175838, 0.01020786166191101, 0.006741601508110762, 0.004022321198135614, 0.002010512864217162, 0.0006265888805501163, -0.00023802171926945448, -0.0007082896772772074, -0.0009126878576353192, -0.0009711346356198192, -0.0009848017944023013, -0.0010285986354574561)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>25</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>25</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>25</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-30</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>25</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_3</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(-0.0010285986354574561, -0.0009848017944023013, -0.0009711346356198192, -0.0009126878576353192, -0.0007082896772772074, -0.00023802171926945448, 0.0006265888805501163, 0.002010512864217162, 0.004022321198135614, 0.006741601508110762, 0.01020786166191101, 0.014412014745175838, 0.019291354343295097, 0.024728646501898766, 0.030555615201592445, 0.036560770124197006, 0.042501047253608704, 0.048116534948349, 0.05314710736274719, 0.05734973028302193, 0.060515083372592926, 0.062482092529535294, 0.06314931064844131, 0.062482092529535294, 0.060515083372592926, 0.05734973028302193, 0.05314710736274719, 0.048116534948349, 0.042501047253608704, 0.036560770124197006, 0.030555615201592445, 0.024728646501898766, 0.019291354343295097, 0.014412014745175838, 0.01020786166191101, 0.006741601508110762, 0.004022321198135614, 0.002010512864217162, 0.0006265888805501163, -0.00023802171926945448, -0.0007082896772772074, -0.0009126878576353192, -0.0009711346356198192, -0.0009848017944023013, -0.0010285986354574561)</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/hocheol/GRC/Sample/ramdisk/centered#9.cfloat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_2</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_3</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_1</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_2</source_block_id><sink_block_id>blocks_null_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_3</source_block_id><sink_block_id>blocks_null_sink_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
