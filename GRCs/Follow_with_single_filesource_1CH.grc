<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Follower117</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sql_on</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>150</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/media/My Passport/Samples/centered#9.cfloat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/hocheol/GRC/Sample/ramdisk/rcvd.cfloat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>-10</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>50</value></param>
<param><key>gate</key><value>False</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>9.349839820060879e-05, -4.944484680891037e-05, -0.00021641614148393273, -0.0004248370532877743, -0.00068991060834378, -0.001021903706714511, -0.0014235575217753649, -0.0018878477858379483, -0.002396312076598406, -0.0029181221034377813, -0.003410042030736804, -0.0038173531647771597, -0.004075761418789625, -0.0041142357513308525, -0.0038586598820984364, -0.003236104268580675, -0.0021794901695102453, -0.0006323619745671749, 0.0014465280110016465, 0.004079130943864584, 0.007264789659529924, 0.010977965779602528, 0.015167188830673695, 0.019755370914936066, 0.02464154176414013, 0.029703939333558083, 0.03480439633131027, 0.039793770760297775, 0.044518183916807175, 0.048825740814208984, 0.052573371678590775, 0.05563344806432724, 0.057899750769138336, 0.059292543679475784, 0.059762392193078995, 0.059292543679475784, 0.057899750769138336, 0.05563344806432724, 0.052573371678590775, 0.048825740814208984, 0.044518183916807175, 0.039793770760297775, 0.03480439633131027, 0.029703939333558083, 0.02464154176414013, 0.019755370914936066, 0.015167188830673695, 0.010977965779602528, 0.007264789659529924, 0.004079130943864584, 0.0014465280110016465, -0.0006323619745671749, -0.0021794901695102453, -0.003236104268580675, -0.0038586598820984364, -0.0041142357513308525, -0.004075761418789625, -0.0038173531647771597, -0.003410042030736804, -0.0029181221034377813, -0.002396312076598406, -0.0018878477858379483, -0.0014235575217753649, -0.001021903706714511, -0.00068991060834378, -0.0004248370532877743, -0.00021641614148393273, -4.944484680891037e-05, 9.349839820060879e-05</value></param>
<param><key>center_freq</key><value>-2.996e6</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
